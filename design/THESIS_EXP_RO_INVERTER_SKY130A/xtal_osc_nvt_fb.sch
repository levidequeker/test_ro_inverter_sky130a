** sch_path: design/THESIS_EXP_RO_INVERTER_SKY130A/xtal_osc_nvt_fb.sch
**.subckt xtal_osc_nvt_fb VDD VSS VSS VSS VOUT_R VOUT_L
*.ipin VDD
*.ipin VSS
*.ipin VSS
*.ipin VSS
*.opin VOUT_R
*.opin VOUT_L
x1 VOUT_R VOUT_L xtal
C1 VOUT_L VSS 6p m=1
C2 VOUT_R VSS 6p m=1
R1 VOUT_L VOUT_R 50Meg m=1
x2 VDD VSS net1 VOUT_L INV_NVT_feedback
x3 VDD VSS VOUT_R net1 INV_NVT_feedback
**.ends

* expanding   symbol:  THESIS_EXP_RO_INVERTER_SKY130A/xtal.sym # of pins=2
** sym_path: design/THESIS_EXP_RO_INVERTER_SKY130A/xtal.sym
** sch_path: design/THESIS_EXP_RO_INVERTER_SKY130A/xtal.sch
.subckt xtal Xtal+ Xtal-
*.iopin Xtal+
*.iopin Xtal-
R1 Xtal+ net1 38.194k m=1
C1 net1 net2 4.68f m=1
L1 net2 Xtal- 5048.571 m=1
C2 Xtal+ Xtal- 1.15p m=1
.ends


* expanding   symbol:  THESIS_EXP_RO_INVERTER_SKY130A/INV_NVT_feedback.sym # of pins=4
** sym_path: design/THESIS_EXP_RO_INVERTER_SKY130A/INV_NVT_feedback.sym
** sch_path: design/THESIS_EXP_RO_INVERTER_SKY130A/INV_NVT_feedback.sch
.subckt INV_NVT_feedback VDD VSS Vout Vin
*.ipin VSS
*.ipin Vin
*.opin Vout
*.ipin VDD
V3 Vout net2 0
.save i(v3)
V4 Vn net1 0
.save i(v4)
V5 net3 Vn 0
.save i(v5)
XM1[2] net2 Vin Vn VSS sky130_fd_pr__nfet_03v3_nvt L=0.6 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XM1[1] net2 Vin Vn VSS sky130_fd_pr__nfet_03v3_nvt L=0.6 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XM1[0] net2 Vin Vn VSS sky130_fd_pr__nfet_03v3_nvt L=0.6 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XM2[4] net1 Vin VSS VSS sky130_fd_pr__nfet_03v3_nvt L=0.6 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XM2[3] net1 Vin VSS VSS sky130_fd_pr__nfet_03v3_nvt L=0.6 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XM2[2] net1 Vin VSS VSS sky130_fd_pr__nfet_03v3_nvt L=0.6 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XM2[1] net1 Vin VSS VSS sky130_fd_pr__nfet_03v3_nvt L=0.6 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XM2[0] net1 Vin VSS VSS sky130_fd_pr__nfet_03v3_nvt L=0.6 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XM4 VDD Vout net3 VSS sky130_fd_pr__nfet_03v3_nvt L=0.6 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XM3[399] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[398] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[397] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[396] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[395] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[394] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[393] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[392] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[391] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[390] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[389] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[388] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[387] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[386] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[385] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[384] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[383] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[382] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[381] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[380] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[379] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[378] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[377] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[376] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[375] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[374] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[373] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[372] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[371] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[370] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[369] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[368] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[367] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[366] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[365] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[364] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[363] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[362] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[361] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[360] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[359] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[358] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[357] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[356] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[355] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[354] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[353] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[352] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[351] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[350] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[349] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[348] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[347] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[346] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[345] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[344] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[343] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[342] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[341] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[340] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[339] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[338] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[337] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[336] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[335] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[334] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[333] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[332] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[331] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[330] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[329] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[328] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[327] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[326] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[325] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[324] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[323] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[322] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[321] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[320] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[319] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[318] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[317] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[316] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[315] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[314] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[313] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[312] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[311] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[310] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[309] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[308] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[307] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[306] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[305] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[304] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[303] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[302] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[301] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[300] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[299] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[298] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[297] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[296] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[295] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[294] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[293] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[292] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[291] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[290] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[289] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[288] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[287] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[286] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[285] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[284] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[283] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[282] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[281] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[280] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[279] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[278] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[277] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[276] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[275] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[274] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[273] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[272] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[271] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[270] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[269] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[268] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[267] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[266] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[265] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[264] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[263] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[262] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[261] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[260] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[259] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[258] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[257] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[256] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[255] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[254] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[253] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[252] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[251] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[250] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[249] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[248] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[247] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[246] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[245] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[244] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[243] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[242] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[241] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[240] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[239] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[238] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[237] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[236] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[235] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[234] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[233] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[232] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[231] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[230] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[229] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[228] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[227] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[226] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[225] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[224] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[223] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[222] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[221] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[220] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[219] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[218] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[217] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[216] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[215] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[214] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[213] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[212] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[211] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[210] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[209] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[208] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[207] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[206] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[205] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[204] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[203] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[202] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[201] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[200] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[199] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[198] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[197] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[196] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[195] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[194] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[193] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[192] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[191] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[190] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[189] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[188] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[187] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[186] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[185] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[184] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[183] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[182] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[181] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[180] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[179] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[178] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[177] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[176] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[175] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[174] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[173] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[172] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[171] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[170] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[169] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[168] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[167] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[166] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[165] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[164] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[163] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[162] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[161] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[160] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[159] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[158] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[157] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[156] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[155] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[154] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[153] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[152] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[151] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[150] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[149] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[148] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[147] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[146] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[145] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[144] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[143] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[142] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[141] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[140] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[139] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[138] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[137] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[136] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[135] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[134] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[133] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[132] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[131] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[130] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[129] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[128] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[127] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[126] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[125] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[124] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[123] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[122] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[121] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[120] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[119] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[118] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[117] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[116] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[115] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[114] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[113] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[112] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[111] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[110] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[109] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[108] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[107] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[106] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[105] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[104] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[103] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[102] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[101] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[100] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[99] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[98] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[97] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[96] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[95] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[94] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[93] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[92] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[91] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[90] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[89] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[88] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[87] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[86] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[85] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[84] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[83] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[82] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[81] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[80] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[79] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[78] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[77] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[76] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[75] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[74] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[73] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[72] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[71] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[70] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[69] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[68] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[67] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[66] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[65] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[64] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[63] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[62] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[61] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[60] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[59] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[58] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[57] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[56] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[55] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[54] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[53] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[52] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[51] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[50] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[49] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[48] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[47] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[46] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[45] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[44] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[43] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[42] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[41] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[40] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[39] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[38] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[37] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[36] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[35] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[34] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[33] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[32] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[31] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[30] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[29] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[28] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[27] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[26] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[25] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[24] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[23] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[22] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[21] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[20] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[19] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[18] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[17] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[16] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[15] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[14] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[13] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[12] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[11] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[10] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[9] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[8] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[7] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[6] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[5] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[4] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[3] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[2] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[1] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[0] net4 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
V1 net4 Vout 0
.save i(v1)
.ends

.end
