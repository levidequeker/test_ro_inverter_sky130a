** sch_path: design/THESIS_EXP_RO_INVERTER_SKY130A/INV_NVT_SCHMITT.sch
**.subckt INV_NVT_SCHMITT VSS Vin Vout VDD
*.ipin VSS
*.ipin Vin
*.opin Vout
*.ipin VDD
V3 Vout net2 0
.save i(v3)
V4 Vn net1 0
.save i(v4)
V5 net3 Vn 0
.save i(v5)
XM1[3] net2 Vin Vn VSS sky130_fd_pr__nfet_03v3_nvt L=0.6 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XM1[2] net2 Vin Vn VSS sky130_fd_pr__nfet_03v3_nvt L=0.6 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XM1[1] net2 Vin Vn VSS sky130_fd_pr__nfet_03v3_nvt L=0.6 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XM1[0] net2 Vin Vn VSS sky130_fd_pr__nfet_03v3_nvt L=0.6 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XM2[4] net1 Vin VSS VSS sky130_fd_pr__nfet_03v3_nvt L=0.6 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XM2[3] net1 Vin VSS VSS sky130_fd_pr__nfet_03v3_nvt L=0.6 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XM2[2] net1 Vin VSS VSS sky130_fd_pr__nfet_03v3_nvt L=0.6 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XM2[1] net1 Vin VSS VSS sky130_fd_pr__nfet_03v3_nvt L=0.6 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XM2[0] net1 Vin VSS VSS sky130_fd_pr__nfet_03v3_nvt L=0.6 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XM4[4] VDD Vout net3 VSS sky130_fd_pr__nfet_03v3_nvt L=0.6 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XM4[3] VDD Vout net3 VSS sky130_fd_pr__nfet_03v3_nvt L=0.6 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XM4[2] VDD Vout net3 VSS sky130_fd_pr__nfet_03v3_nvt L=0.6 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XM4[1] VDD Vout net3 VSS sky130_fd_pr__nfet_03v3_nvt L=0.6 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XM4[0] VDD Vout net3 VSS sky130_fd_pr__nfet_03v3_nvt L=0.6 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[399] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[398] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[397] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[396] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[395] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[394] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[393] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[392] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[391] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[390] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[389] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[388] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[387] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[386] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[385] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[384] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[383] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[382] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[381] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[380] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[379] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[378] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[377] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[376] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[375] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[374] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[373] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[372] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[371] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[370] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[369] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[368] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[367] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[366] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[365] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[364] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[363] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[362] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[361] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[360] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[359] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[358] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[357] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[356] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[355] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[354] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[353] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[352] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[351] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[350] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[349] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[348] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[347] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[346] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[345] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[344] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[343] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[342] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[341] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[340] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[339] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[338] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[337] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[336] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[335] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[334] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[333] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[332] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[331] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[330] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[329] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[328] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[327] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[326] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[325] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[324] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[323] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[322] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[321] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[320] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[319] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[318] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[317] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[316] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[315] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[314] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[313] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[312] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[311] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[310] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[309] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[308] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[307] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[306] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[305] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[304] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[303] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[302] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[301] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[300] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[299] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[298] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[297] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[296] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[295] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[294] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[293] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[292] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[291] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[290] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[289] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[288] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[287] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[286] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[285] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[284] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[283] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[282] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[281] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[280] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[279] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[278] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[277] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[276] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[275] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[274] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[273] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[272] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[271] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[270] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[269] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[268] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[267] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[266] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[265] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[264] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[263] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[262] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[261] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[260] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[259] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[258] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[257] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[256] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[255] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[254] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[253] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[252] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[251] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[250] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[249] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[248] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[247] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[246] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[245] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[244] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[243] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[242] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[241] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[240] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[239] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[238] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[237] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[236] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[235] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[234] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[233] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[232] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[231] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[230] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[229] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[228] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[227] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[226] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[225] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[224] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[223] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[222] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[221] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[220] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[219] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[218] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[217] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[216] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[215] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[214] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[213] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[212] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[211] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[210] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[209] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[208] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[207] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[206] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[205] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[204] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[203] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[202] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[201] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[200] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[199] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[198] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[197] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[196] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[195] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[194] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[193] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[192] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[191] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[190] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[189] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[188] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[187] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[186] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[185] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[184] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[183] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[182] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[181] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[180] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[179] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[178] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[177] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[176] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[175] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[174] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[173] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[172] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[171] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[170] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[169] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[168] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[167] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[166] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[165] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[164] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[163] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[162] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[161] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[160] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[159] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[158] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[157] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[156] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[155] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[154] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[153] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[152] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[151] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[150] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[149] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[148] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[147] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[146] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[145] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[144] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[143] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[142] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[141] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[140] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[139] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[138] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[137] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[136] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[135] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[134] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[133] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[132] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[131] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[130] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[129] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[128] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[127] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[126] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[125] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[124] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[123] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[122] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[121] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[120] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[119] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[118] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[117] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[116] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[115] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[114] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[113] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[112] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[111] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[110] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[109] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[108] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[107] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[106] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[105] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[104] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[103] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[102] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[101] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[100] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[99] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[98] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[97] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[96] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[95] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[94] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[93] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[92] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[91] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[90] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[89] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[88] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[87] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[86] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[85] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[84] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[83] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[82] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[81] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[80] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[79] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[78] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[77] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[76] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[75] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[74] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[73] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[72] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[71] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[70] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[69] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[68] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[67] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[66] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[65] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[64] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[63] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[62] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[61] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[60] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[59] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[58] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[57] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[56] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[55] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[54] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[53] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[52] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[51] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[50] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[49] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[48] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[47] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[46] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[45] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[44] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[43] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[42] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[41] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[40] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[39] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[38] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[37] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[36] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[35] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[34] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[33] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[32] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[31] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[30] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[29] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[28] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[27] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[26] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[25] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[24] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[23] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[22] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[21] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[20] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[19] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[18] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[17] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[16] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[15] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[14] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[13] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[12] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[11] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[10] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[9] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[8] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[7] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[6] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[5] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[4] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[3] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[2] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[1] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[0] net4 Vin Vp VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
V1 net4 Vout 0
.save i(v1)
XM5[499] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[498] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[497] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[496] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[495] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[494] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[493] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[492] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[491] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[490] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[489] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[488] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[487] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[486] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[485] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[484] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[483] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[482] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[481] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[480] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[479] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[478] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[477] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[476] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[475] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[474] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[473] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[472] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[471] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[470] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[469] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[468] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[467] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[466] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[465] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[464] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[463] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[462] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[461] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[460] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[459] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[458] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[457] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[456] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[455] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[454] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[453] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[452] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[451] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[450] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[449] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[448] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[447] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[446] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[445] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[444] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[443] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[442] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[441] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[440] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[439] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[438] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[437] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[436] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[435] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[434] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[433] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[432] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[431] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[430] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[429] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[428] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[427] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[426] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[425] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[424] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[423] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[422] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[421] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[420] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[419] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[418] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[417] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[416] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[415] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[414] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[413] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[412] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[411] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[410] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[409] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[408] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[407] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[406] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[405] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[404] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[403] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[402] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[401] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[400] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[399] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[398] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[397] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[396] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[395] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[394] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[393] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[392] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[391] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[390] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[389] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[388] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[387] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[386] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[385] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[384] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[383] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[382] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[381] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[380] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[379] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[378] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[377] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[376] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[375] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[374] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[373] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[372] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[371] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[370] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[369] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[368] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[367] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[366] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[365] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[364] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[363] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[362] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[361] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[360] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[359] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[358] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[357] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[356] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[355] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[354] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[353] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[352] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[351] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[350] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[349] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[348] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[347] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[346] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[345] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[344] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[343] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[342] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[341] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[340] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[339] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[338] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[337] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[336] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[335] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[334] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[333] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[332] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[331] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[330] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[329] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[328] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[327] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[326] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[325] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[324] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[323] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[322] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[321] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[320] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[319] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[318] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[317] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[316] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[315] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[314] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[313] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[312] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[311] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[310] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[309] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[308] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[307] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[306] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[305] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[304] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[303] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[302] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[301] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[300] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[299] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[298] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[297] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[296] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[295] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[294] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[293] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[292] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[291] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[290] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[289] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[288] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[287] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[286] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[285] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[284] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[283] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[282] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[281] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[280] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[279] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[278] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[277] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[276] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[275] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[274] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[273] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[272] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[271] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[270] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[269] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[268] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[267] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[266] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[265] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[264] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[263] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[262] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[261] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[260] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[259] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[258] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[257] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[256] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[255] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[254] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[253] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[252] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[251] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[250] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[249] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[248] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[247] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[246] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[245] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[244] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[243] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[242] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[241] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[240] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[239] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[238] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[237] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[236] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[235] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[234] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[233] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[232] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[231] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[230] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[229] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[228] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[227] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[226] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[225] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[224] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[223] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[222] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[221] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[220] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[219] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[218] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[217] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[216] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[215] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[214] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[213] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[212] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[211] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[210] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[209] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[208] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[207] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[206] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[205] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[204] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[203] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[202] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[201] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[200] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[199] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[198] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[197] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[196] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[195] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[194] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[193] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[192] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[191] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[190] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[189] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[188] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[187] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[186] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[185] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[184] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[183] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[182] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[181] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[180] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[179] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[178] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[177] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[176] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[175] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[174] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[173] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[172] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[171] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[170] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[169] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[168] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[167] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[166] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[165] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[164] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[163] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[162] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[161] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[160] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[159] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[158] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[157] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[156] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[155] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[154] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[153] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[152] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[151] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[150] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[149] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[148] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[147] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[146] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[145] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[144] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[143] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[142] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[141] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[140] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[139] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[138] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[137] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[136] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[135] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[134] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[133] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[132] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[131] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[130] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[129] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[128] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[127] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[126] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[125] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[124] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[123] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[122] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[121] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[120] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[119] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[118] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[117] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[116] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[115] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[114] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[113] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[112] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[111] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[110] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[109] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[108] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[107] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[106] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[105] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[104] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[103] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[102] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[101] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[100] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[99] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[98] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[97] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[96] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[95] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[94] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[93] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[92] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[91] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[90] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[89] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[88] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[87] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[86] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[85] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[84] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[83] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[82] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[81] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[80] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[79] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[78] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[77] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[76] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[75] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[74] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[73] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[72] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[71] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[70] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[69] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[68] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[67] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[66] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[65] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[64] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[63] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[62] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[61] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[60] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[59] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[58] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[57] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[56] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[55] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[54] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[53] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[52] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[51] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[50] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[49] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[48] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[47] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[46] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[45] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[44] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[43] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[42] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[41] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[40] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[39] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[38] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[37] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[36] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[35] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[34] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[33] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[32] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[31] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[30] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[29] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[28] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[27] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[26] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[25] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[24] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[23] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[22] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[21] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[20] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[19] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[18] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[17] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[16] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[15] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[14] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[13] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[12] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[11] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[10] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[9] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[8] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[7] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[6] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[5] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[4] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[3] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[2] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[1] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5[0] net6 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[199] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[198] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[197] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[196] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[195] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[194] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[193] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[192] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[191] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[190] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[189] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[188] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[187] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[186] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[185] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[184] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[183] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[182] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[181] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[180] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[179] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[178] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[177] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[176] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[175] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[174] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[173] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[172] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[171] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[170] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[169] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[168] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[167] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[166] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[165] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[164] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[163] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[162] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[161] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[160] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[159] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[158] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[157] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[156] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[155] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[154] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[153] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[152] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[151] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[150] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[149] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[148] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[147] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[146] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[145] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[144] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[143] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[142] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[141] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[140] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[139] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[138] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[137] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[136] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[135] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[134] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[133] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[132] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[131] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[130] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[129] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[128] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[127] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[126] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[125] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[124] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[123] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[122] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[121] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[120] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[119] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[118] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[117] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[116] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[115] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[114] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[113] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[112] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[111] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[110] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[109] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[108] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[107] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[106] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[105] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[104] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[103] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[102] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[101] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[100] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[99] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[98] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[97] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[96] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[95] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[94] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[93] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[92] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[91] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[90] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[89] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[88] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[87] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[86] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[85] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[84] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[83] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[82] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[81] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[80] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[79] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[78] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[77] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[76] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[75] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[74] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[73] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[72] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[71] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[70] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[69] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[68] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[67] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[66] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[65] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[64] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[63] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[62] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[61] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[60] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[59] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[58] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[57] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[56] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[55] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[54] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[53] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[52] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[51] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[50] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[49] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[48] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[47] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[46] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[45] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[44] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[43] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[42] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[41] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[40] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[39] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[38] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[37] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[36] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[35] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[34] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[33] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[32] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[31] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[30] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[29] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[28] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[27] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[26] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[25] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[24] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[23] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[22] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[21] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[20] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[19] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[18] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[17] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[16] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[15] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[14] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[13] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[12] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[11] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[10] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[9] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[8] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[7] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[6] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[5] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[4] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[3] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[2] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[1] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6[0] VSS Vout net5 VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
V2 net6 Vp 0
.save i(v2)
V6 net5 Vp 0
.save i(v6)
**.ends
.end
