** sch_path: design/THESIS_EXP_RO_INVERTER_SKY130A/INV_LVT_NVT.sch
**.subckt INV_LVT_NVT VSS Vin Vout VDD
*.ipin VSS
*.ipin Vin
*.opin Vout
*.ipin VDD
V3 Vout net1 0
.save i(v3)
XM1 net1 Vin VSS VSS sky130_fd_pr__nfet_03v3_nvt L=0.6 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XM3[699] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[698] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[697] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[696] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[695] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[694] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[693] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[692] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[691] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[690] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[689] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[688] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[687] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[686] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[685] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[684] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[683] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[682] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[681] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[680] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[679] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[678] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[677] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[676] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[675] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[674] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[673] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[672] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[671] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[670] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[669] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[668] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[667] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[666] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[665] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[664] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[663] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[662] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[661] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[660] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[659] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[658] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[657] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[656] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[655] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[654] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[653] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[652] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[651] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[650] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[649] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[648] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[647] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[646] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[645] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[644] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[643] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[642] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[641] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[640] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[639] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[638] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[637] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[636] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[635] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[634] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[633] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[632] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[631] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[630] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[629] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[628] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[627] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[626] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[625] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[624] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[623] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[622] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[621] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[620] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[619] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[618] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[617] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[616] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[615] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[614] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[613] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[612] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[611] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[610] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[609] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[608] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[607] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[606] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[605] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[604] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[603] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[602] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[601] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[600] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[599] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[598] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[597] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[596] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[595] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[594] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[593] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[592] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[591] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[590] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[589] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[588] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[587] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[586] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[585] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[584] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[583] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[582] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[581] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[580] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[579] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[578] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[577] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[576] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[575] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[574] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[573] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[572] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[571] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[570] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[569] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[568] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[567] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[566] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[565] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[564] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[563] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[562] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[561] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[560] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[559] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[558] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[557] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[556] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[555] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[554] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[553] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[552] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[551] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[550] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[549] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[548] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[547] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[546] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[545] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[544] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[543] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[542] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[541] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[540] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[539] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[538] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[537] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[536] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[535] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[534] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[533] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[532] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[531] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[530] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[529] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[528] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[527] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[526] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[525] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[524] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[523] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[522] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[521] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[520] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[519] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[518] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[517] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[516] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[515] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[514] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[513] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[512] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[511] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[510] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[509] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[508] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[507] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[506] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[505] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[504] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[503] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[502] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[501] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[500] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[499] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[498] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[497] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[496] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[495] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[494] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[493] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[492] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[491] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[490] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[489] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[488] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[487] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[486] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[485] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[484] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[483] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[482] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[481] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[480] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[479] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[478] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[477] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[476] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[475] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[474] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[473] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[472] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[471] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[470] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[469] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[468] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[467] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[466] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[465] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[464] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[463] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[462] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[461] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[460] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[459] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[458] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[457] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[456] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[455] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[454] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[453] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[452] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[451] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[450] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[449] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[448] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[447] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[446] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[445] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[444] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[443] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[442] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[441] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[440] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[439] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[438] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[437] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[436] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[435] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[434] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[433] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[432] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[431] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[430] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[429] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[428] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[427] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[426] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[425] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[424] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[423] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[422] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[421] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[420] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[419] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[418] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[417] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[416] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[415] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[414] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[413] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[412] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[411] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[410] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[409] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[408] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[407] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[406] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[405] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[404] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[403] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[402] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[401] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[400] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[399] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[398] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[397] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[396] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[395] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[394] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[393] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[392] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[391] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[390] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[389] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[388] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[387] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[386] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[385] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[384] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[383] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[382] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[381] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[380] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[379] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[378] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[377] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[376] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[375] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[374] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[373] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[372] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[371] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[370] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[369] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[368] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[367] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[366] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[365] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[364] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[363] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[362] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[361] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[360] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[359] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[358] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[357] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[356] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[355] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[354] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[353] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[352] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[351] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[350] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[349] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[348] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[347] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[346] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[345] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[344] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[343] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[342] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[341] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[340] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[339] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[338] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[337] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[336] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[335] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[334] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[333] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[332] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[331] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[330] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[329] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[328] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[327] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[326] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[325] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[324] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[323] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[322] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[321] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[320] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[319] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[318] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[317] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[316] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[315] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[314] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[313] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[312] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[311] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[310] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[309] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[308] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[307] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[306] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[305] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[304] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[303] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[302] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[301] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[300] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[299] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[298] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[297] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[296] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[295] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[294] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[293] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[292] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[291] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[290] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[289] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[288] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[287] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[286] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[285] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[284] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[283] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[282] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[281] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[280] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[279] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[278] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[277] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[276] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[275] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[274] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[273] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[272] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[271] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[270] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[269] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[268] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[267] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[266] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[265] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[264] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[263] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[262] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[261] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[260] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[259] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[258] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[257] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[256] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[255] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[254] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[253] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[252] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[251] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[250] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[249] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[248] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[247] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[246] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[245] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[244] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[243] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[242] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[241] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[240] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[239] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[238] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[237] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[236] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[235] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[234] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[233] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[232] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[231] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[230] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[229] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[228] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[227] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[226] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[225] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[224] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[223] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[222] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[221] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[220] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[219] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[218] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[217] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[216] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[215] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[214] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[213] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[212] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[211] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[210] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[209] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[208] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[207] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[206] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[205] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[204] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[203] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[202] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[201] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[200] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[199] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[198] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[197] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[196] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[195] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[194] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[193] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[192] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[191] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[190] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[189] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[188] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[187] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[186] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[185] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[184] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[183] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[182] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[181] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[180] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[179] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[178] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[177] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[176] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[175] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[174] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[173] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[172] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[171] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[170] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[169] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[168] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[167] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[166] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[165] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[164] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[163] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[162] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[161] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[160] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[159] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[158] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[157] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[156] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[155] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[154] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[153] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[152] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[151] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[150] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[149] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[148] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[147] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[146] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[145] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[144] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[143] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[142] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[141] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[140] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[139] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[138] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[137] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[136] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[135] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[134] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[133] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[132] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[131] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[130] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[129] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[128] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[127] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[126] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[125] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[124] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[123] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[122] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[121] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[120] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[119] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[118] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[117] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[116] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[115] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[114] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[113] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[112] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[111] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[110] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[109] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[108] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[107] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[106] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[105] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[104] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[103] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[102] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[101] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[100] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[99] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[98] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[97] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[96] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[95] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[94] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[93] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[92] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[91] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[90] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[89] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[88] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[87] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[86] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[85] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[84] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[83] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[82] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[81] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[80] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[79] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[78] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[77] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[76] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[75] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[74] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[73] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[72] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[71] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[70] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[69] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[68] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[67] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[66] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[65] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[64] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[63] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[62] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[61] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[60] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[59] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[58] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[57] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[56] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[55] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[54] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[53] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[52] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[51] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[50] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[49] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[48] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[47] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[46] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[45] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[44] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[43] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[42] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[41] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[40] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[39] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[38] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[37] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[36] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[35] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[34] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[33] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[32] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[31] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[30] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[29] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[28] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[27] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[26] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[25] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[24] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[23] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[22] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[21] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[20] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[19] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[18] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[17] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[16] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[15] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[14] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[13] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[12] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[11] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[10] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[9] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[8] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[7] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[6] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[5] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[4] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[3] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[2] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[1] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3[0] net2 Vin VDD VDD sky130_fd_pr__pfet_01v8_lvt L=0.35 W=7 nf=1 ad='int((1 + 1)/2) * 7 / 1 * 0.29'
+ as='int((1 + 2)/2) * 7 / 1 * 0.29' pd='2*int((1 + 1)/2) * (7 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (7 / 1 + 0.29)'
+ nrd='0.29 / 7 ' nrs='0.29 / 7 ' sa=0 sb=0 sd=0 mult=1 m=1
V1 net2 Vout 0
.save i(v1)
**.ends
.end
