v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {jnw_native_atr_sky130A/design/JNW_NTV_ATR_SKY130A/JNW_NTV_ATR_3V3_W10_L4.sym} 0 0 0 0 {name=x1}
C {devices/ipin.sym} 30 -30 1 0 {name=p1 lab=VD}
C {devices/ipin.sym} 30 30 3 0 {name=p2 lab=VS}
C {devices/ipin.sym} 0 0 0 0 {name=p3 lab=VG}
